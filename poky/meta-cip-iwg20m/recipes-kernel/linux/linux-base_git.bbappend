# Copyright (C) 2016-2017, TOSHIBA Corp., Daniel Sangorrin <daniel.sangorrin@toshiba.co.jp>
# SPDX-License-Identifier:	MIT

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://default.config"
