# Enable bitbanging for NXP IMX processors
EXTRA_OECONF += "--enable-imx_gpio"
