RDEPENDS_${PN} += " \
    nativesdk-u-boot-mkimage \
"
